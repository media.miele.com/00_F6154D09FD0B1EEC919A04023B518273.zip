Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-11-10T08:24:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 10 08:24:40 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{3BF0DE38-1B59-485F-8DF0-439D11E7ECBA}\ifc * Database version: 5507 * Database creation date: Wed Nov 10 08:24:39 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 10 08:24:40 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 10 08:24:40 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 23786033_USA_11876990_DGC7860_GRGR, 11876990_USA_DGC7860_GRGR:23786033_USA_11876990_DGC7860_GRGR:205866
In: Level 1
Type - Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR, z_Miele_Design_Glass Black
Pset_BuildingElementProxyCommon - Reference: 23786033_USA_11876990_DGC7860_GRGR
